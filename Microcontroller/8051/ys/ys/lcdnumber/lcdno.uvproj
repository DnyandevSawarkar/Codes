# Keil uVision project lcdno.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(33000000) MODAT2
  output: lcdno +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    D:/svpcet/module1/program/lcd_impp/lcdnumber/: STARTUP.A51
    ./: lcdno.c
